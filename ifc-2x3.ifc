Properties of the parts of a building model (IFC2X3)

# File
Description: Funk-Heizungsaktor, Aufputz, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: BA110500, Funk-Heizungsaktor, Aufputz
In: Raum
Description: Funkaktoren (Funk-Heizungsregler), die in Verbindung mit alre-Funk-Raumtemperatursensoren eine Einzelraum-Temperaturregelung verwirklichen. Anwendung überwiegend im Sanierungsbereich oder bei Heizungsanlagenerweiterungen. 1-Kanal Funk-Temperaturaktor für Elektrodirektheizungen, Natursteinheizungen.; Classification: EC000436 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: BA110500; ModelLabel: HTFRB-010.101; GlobalTradeItemNumber: 4050528015099; ProductURL: https://alre.de/produkt_BA110500
Pset_Specification - NominalLength: 0.0834 m; NominalWidth: 0.0783 m; NominalDepth: 0.0255 m; NetWeight: 0.088
Pset_ALRE_ETIM_Properties - Montageart: Unterputz; Farbe: weiß; Stromversorgung: 230 V AC; Anzahl der Relais: 1; Werkstoffgüte: Thermoplast; Werkstoff: Kunststoff; Funkfrequenz: 868.3; RAL-Nummer (ähnlich): 9010; Ausführung der Oberfläche: matt; Geeignet für Schutzart (IP): IP30; ETIM-Klasse: EC000436; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-BA110500.pdf
